# Keil uVision project ommocom_bootload.uvprojx, settings and files
target ommocom_bootload (6190000::V6.19::ARMCLANG)
  device: STM32C011F6Ux STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: ommocom_bootload +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=48000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=48000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32C011xx
  c include: ../Core/Inc;../Drivers/STM32C0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32C0xx/Include;../Drivers/CMSIS/Include;..\Core\drivefile\hfile
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Application/MDK-ARM
    ./: startup_stm32c011xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c crc.c tim.c usart.c stm32c0xx_it.c
    ../Core/drivefile/: stm32c0xx_hal.c stm32c0xx_hal_cortex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c
  group Drivers/STM32C0xx_HAL_Driver
    ../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_ll_gpio.c stm32c0xx_ll_exti.c stm32c0xx_ll_rcc.c stm32c0xx_ll_utils.c stm32c0xx_ll_crc.c stm32c0xx_ll_pwr.c stm32c0xx_ll_tim.c stm32c0xx_ll_dma.c stm32c0xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32c0xx.c
software components: CMSIS:CORE 4.3.0
